# Keil uVision project FLB-PIDtest.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: FLB-PIDtest +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Angle.c main.c pwm.c Mode1.c key.c
